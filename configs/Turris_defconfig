## configs/Turris_defconfig
```kconfig
CONFIG_SYS_EXTRA_OPTIONS="TURRIS"
CONFIG_PPC=y
CONFIG_MPC85xx=y
CONFIG_TARGET_TURRIS=y
```
